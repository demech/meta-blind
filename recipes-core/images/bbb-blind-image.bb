require recipes-core/images/core-image-minimal.bb

PR := "r1"

IMAGE_INSTALL += ""

